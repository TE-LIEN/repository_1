# Keil uVision project sensminiA4Neo.uvprojx, settings and files
target Release (6240000::V6.24::ARMCLANG)
  device: M467J2JHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: sensminiA4Neo
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: SENSMINIA4_NEO RELEASE_VERSION NUVOTON HBI_ENABLE=1 SUPPORT_USB_HOST TCP_CLIENT_CFG_MBEDTLS_ENABLE HTTPSRV_CFG_MBEDTLS_ENABLE=1 HAVE_BOOTLOADER
  c include: ..\Src\headers;..\..\Library\StdDriver\inc;..\Src;..\..\ThirdParty\FreeRTOS\Source;..\..\ThirdParty\FreeRTOS\Source\include;..\..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\..\Library\Device\Nuvoton\m460\Include;..\..\Library\CMSIS\Include;..\..\Kernel\OSA;..\..\ThirdParty\lwip\src\include;..\..\ThirdParty\lwip\ports\include;..\..\ThirdParty\littleFs;..\..\Library\UsbHostLib\inc;..\Src\FatFs\src;..\..\ThirdParty\mbedTLS\include;..\..\ThirdParty\mbedTLS\port;..\..\ThirdParty\mbedTLS\port\nuvoton
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\sensminiA4Neo.sct
  group System
    ../../Library/Device/Nuvoton/m460/Source/: system_m460.c
    ../../Library/Device/Nuvoton/m460/Source/ARM/: startup_m460.S
  group Sys_Headers
    ../Src/: compiler_settings.h deviceEnum.h deviceConfig.h
    ../Src/headers/: boardDef.h sensminiCfg.h taskDef.h sysStruct.h sysConfig.h sysEnum.h networkStruct.h networkEnum.h networkConfig.h deviceStruct.h gpioEnum.h mqttEnum.h otaConfig.h
  group App
    ../Src/: main.c sensSystem.c sensSystem.h rtcDateTime.c rtcDateTime.h sensCommon.c sensCommon.h powerCtrl.c powerCtrl.h sdCardTask.c sdCardTask.h sensDev.c sensDev.h systemCtrl.c param.c param.h physicalQuantity.c physicalQuantity.h systemTimer.c systemTimer.h Ini.c Ini2.c Ini.h Ini2.h AutoDataSync.c AutoDataSync.h expanderGpioTask.c expanderGpioTask.h test_fw.c
  group CJSON
    ../Src/cJSON/: cJSON.c cJSON_Utils.c cJSON.h cJSON_Utils.h
  group App_Library
    ../../ThirdParty/FreeRTOS/Objects/: freeRTOSLib.lib
    ../../ThirdParty/lwip/Objects/: lwipLib.lib
    ../../ThirdParty/mbedTLS/Objects/: mbedTls.lib
  group M467_StdLib
    ../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c gpio.c hbi.c rtc.c qspi.c spi.c pdma.c i2c.c sdh.c fmc.c crypto.c rng.c keystore.c eadc.c timer.c wdt.c crc.c
  group OSA
    ../../Kernel/OSA/: osa.c osa.h
  group FSA
    ../Src/FS/: FSA_FS.c fsCtrl.c FSA_FS.h fsCtrl.h
  group HAL
    ../Src/HAL/: HAL_CONFIG.h HAL_UART.h HAL_UART.c
  group EMAC
    ../Src/drv_emac/: m460_emac.c m460_mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c ethernetif.c
  group NET_APP
    ../../ThirdParty/lwip/src/apps/sntp/: sntp.c
    ../Src/network/: dnsService.c dnsService.h ethernetService.c ethernetService.h networkProcessTask.c networkProcessTask.h netApp.h iotProcessTask.c iotProcessTask.h iotProcessApp.c iotProcessApp.h cmux.c cmux.h modem_ppp.c modem_ppp.h networkProcessApp.c networkProcessApp.h tcpTls.c tcpTls.h cgi.c cgi.h otaProcessApp.c otaProcessApp.h
    ../Src/network/httpsrv/web/: tfs_data_A4Neo.c
  group NET_PROTOCOL
    ../Src/network/Protocol/: serverCmdProcessTask.c serverCmdProcessTask.h serverProtocol.h serverCmdProcessApp.c serverCmdProcessApp.h HttpClientProtocol.c HttpClientProtocol.h ioaProt.c ioaProt.h SenstalkProtocol.c SenstalkProtocol.h SenstalkMqttProtocol.c SenstalkMqttProtocol.h MqttProtocolProcess.c MqttProtocolProcess.h SensscfgMqttProtocol.c SensscfgMqttProtocol.h
  group LittleFs
    ../../ThirdParty/littleFs/: lfs.c lfs_util.c lfs.h lfs_util.h
    ../Src/littleFs/: littleFsPort.c littleFsPort.h
  group Driver
    ../Src/driver/: spiNorFalsh.c spiNorFlash.h SENS_SPI.c SENS_SPI.h i2cDrv.c i2cDrv.h s35710WakeupTimer.c s35710WakeupTimer.h PCAL6416GpioExpander.c PCAL6416GpioExpander.h tcn75a.c tcn75a.h i2cEeprom.c i2cEeprom.h ad7124Adc.c ad7124Adc.h uartDrv.c uartDrv.h
  group USB_HOST_CORE
    ../../Library/UsbHostLib/src_core/: ehci.c ehci_iso.c hub.c mem_alloc.c ohci.c usb_core.c
  group USB_HOST_CLASS
    ../../Library/UsbHostLib/src_cdc/: cdc_core.c cdc_driver.c cdc_parser.c
    ../../Library/UsbHostLib/src_uvc/: uvc_core.c uvc_driver.c uvc_parser.c
  group USB_HOST_PROCESS
    ../Src/usbHost/: usbHostTask.c usbHostTask.h
  group FAT_FS
    ../Src/FatFs/src/: diskio.c ff.c ffsystem.c ffunicode.c SDGlue.c ff.h ffconf.h ffsConfig.h integer.h diskio.h
  group SENSORS
    ../Src/sensors/: cameraUvcSensor.c cameraUvcSensor.h sensorTask.c sensorTask.h sensorApp.h onboardTempSensor.c onboardTempSensor.h aiSensor.c aiSensor.h modbusApp.c modbusApp.h dconApp.c dconApp.h radarSensor.c radarSensor.h voltSense.c voltSense.h displayPanelSensor.c displayPanelSensor.h
  group MbedTLS_PORT
    ../../ThirdParty/mbedTLS/port/nuvoton/: aes_alt.c des_alt.c ecp_internal_alt.c sha_alt_hw.c sha1_alt.c sha1_alt_sw.c sha256_alt.c sha256_alt_sw.c sha512_alt.c sha512_alt_sw.c cryptoMisc.c cryptoMisc.h ecp_alt.c ecp_alt.h ecp_curves_alt.c crypto_ecc_hw.c crypto_rsa_hw.c ecp_helper.c rsa_alt.c crypto_rsa_hw.h rsa_alt.h
  group MQTT_LIB
    ../Src/network/mqtt/: mqtt_client.c mqtt_packet.c mqtt_socket.c mqttConfig.c mqttnet.c mqtt_client.h mqtt_packet.h mqtt_socket.h mqtt_types.h mqttConfig.h mqttnet.h options.h version.h visibility.h vs_settings.h
    ../Src/network/: mqttclientTask.c mqttclientTask.h
  group HTTP_SERVER
    ../Src/network/httpsrv/: httpsrv.c httpsrv_base64.c httpsrv_fs.c httpsrv_script.c httpsrv_sha1.c httpsrv_supp.c httpsrv_task.c httpsrv_tls.c httpsrv_utf8.c httpsrv_ws.c httpsrv_ws_api.c httpsrv.h httpsrv_base64.h httpsrv_config.h httpsrv_fs.h httpsrv_port.h httpsrv_prv.h httpsrv_script.h httpsrv_sha1.h httpsrv_supp.h httpsrv_tls.h httpsrv_utf8.h httpsrv_ws.h httpsrv_ws_prv.h
  group MODBUS
    ../Src/sensors/modbus/: modbus.c modbus-data.c modbus-rtu.c modbus-tcp.c modbus.h modbus-private.h modbus-rtu.h modbus-rtu-private.h modbus-tcp.h modbus-tcp-private.h modbus-version.h
  group Peripheral
    ../Src/PERIPHERAL/: rs485.c rs485.h
