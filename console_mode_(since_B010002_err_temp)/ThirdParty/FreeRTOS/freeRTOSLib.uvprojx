# Keil uVision project freeRTOSLib.uvprojx, settings and files
target FreeRTOS (6240000::V6.24::ARMCLANG)
  device: M467JJHAE Nuvoton
  pack: Nuvoton.NuMicroM4_DFP.1.0.1
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: freeRTOSLib (library)
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Source\include;.\Source\portable\GCC\ARM_CM4F;.\Source
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group src
    ./Source/: event_groups.c list.c queue.c tasks.c timers.c FreeRTOSConfig.h
    ./Source/portable/MemMang/: heap_5.c
    ./Source/portable/GCC/ARM_CM4F/: port.c
